FILESEXTRAPATHS_prepend := "${THISDIR}/linux-nai:"

#Kernel config 
#SRC_URI += "file://nai_75g5-x2_defconfig"
#KERNEL_DEFCONFIG_75g5-x2 = "nai_75g5-x2_defconfig"

#If we need to patch the kernel manually, use this list here. 
#SRC_URI_append += " file://2018_LinuxKernel_xilinxVSnai.patch" #already applied in the gittree branch, 75g5-x2
#SRC_URI_append += "file://patch_NUMBER_TWO.patch"
#SRC_URI_append += "file://patch_NUMBER_THREE.patch"


