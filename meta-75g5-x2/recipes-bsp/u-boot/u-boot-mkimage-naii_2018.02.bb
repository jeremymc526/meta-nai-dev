require u-boot-mkimage-naii.inc
